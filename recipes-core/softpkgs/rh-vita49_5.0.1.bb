DESCRIPTION = "REDHAWK VITA49 Libraries SoftPkg"

PR = "3"

require core-cpp-softpkg.inc

SOFTPKG_NAME = "VITA49"
