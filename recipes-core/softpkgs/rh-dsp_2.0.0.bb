DESCRIPTION = "REDHAWK DSP SoftPkg"

PR = "5"

SOFTPKG_NAME = "dsp"

require core-cpp-softpkg.inc
