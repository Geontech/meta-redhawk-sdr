DESCRIPTION = "REDHAWK BlueFile Lib SoftPkg"

PR = "4"

SOFTPKG_NAME = "blueFileLib"

require core-cpp-softpkg.inc
