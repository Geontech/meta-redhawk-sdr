DESCRIPTION = "REDHAWK Source Socket Component"

DEPENDS = "bulkiointerfaces"
RDEPENDS_${PN} = "bulkiointerfaces"

PR = "3"

require core-cpp-component.inc
