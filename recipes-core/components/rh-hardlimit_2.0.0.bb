DESCRIPTION = "REDHAWK File Reader Component (CPP)"

DEPENDS = "bulkiointerfaces"
RDEPENDS_${PN} = "bulkiointerfaces"

PR = "5"

require core-cpp-component.inc
