DESCRIPTION = "REDHAWK SourceSDDS Component"

DEPENDS = "bulkiointerfaces"
RDEPENDS_${PN} = "bulkiointerfaces"

PR = "4"

require core-cpp-component.inc
