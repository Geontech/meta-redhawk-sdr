DESCRIPTION = "REDHAWK Sink Socket Component"

DEPENDS = "bulkiointerfaces"
RDEPENDS_${PN} = "bulkiointerfaces"

PR = "5"

require core-cpp-component.inc
