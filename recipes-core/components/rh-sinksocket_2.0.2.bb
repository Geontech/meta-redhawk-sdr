DESCRIPTION = "REDHAWK Sink Socket Component"

DEPENDS = "bulkiointerfaces"
RDEPENDS_${PN} = "bulkiointerfaces"

PR = "1"

require core-cpp-component.inc
