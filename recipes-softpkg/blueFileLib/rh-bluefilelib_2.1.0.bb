DESCRIPTION = "REDHAWK BlueFile Lib SoftPkg"

PR = "r4"

# The core-cpp-softpkg class hierarchy handles ...a lot.
inherit redhawk-core-cpp-softpkg
