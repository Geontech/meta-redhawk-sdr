DESCRIPTION = "REDHAWK BlueFile Lib SoftPkg"

PR = "r1"

# The core-cpp-softpkg class hierarchy handles ...a lot.
inherit redhawk-core-cpp-softpkg
