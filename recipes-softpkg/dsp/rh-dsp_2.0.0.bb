DESCRIPTION = "REDHAWK DSP SoftPkg"

PR = "r5"

# The core-cpp-softpkg class hierarchy handles ...a lot.
inherit redhawk-core-cpp-softpkg
