DESCRIPTION = "REDHAWK VITA49 Libraries SoftPkg"

PR = "r3"

# The core-cpp-softpkg class hierarchy handles ...a lot.
inherit redhawk-core-cpp-softpkg

# This library location in the main repo is VITA49Libraries
SOFTPKG_REPO_DIR = "VITA49Libraries"
